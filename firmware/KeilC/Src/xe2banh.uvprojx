# Keil uVision project xe2banh.uvprojx, settings and files
target xe2banh (6140000::V6.14::ARMCLANG)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: xe2banh
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F10X_MD
  c include: ..\Inc
  asm include: ..\Inc
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group main
    ../Inc/: mpu6050.h systick_delay.h usbttl.h PID.h
    ./: mpu6050.c systick_delay.c main.c motor.c usbttl.c PID.c
  group CMSIS
    ./: system_stm32f10x.c
  group startup
    ../Startup/: startup_stm32f10x_md.s
  group my_lib
    ./: gpio.c stm32f10x_it.c SysClock.c
